# Keil uVision project testboard.uvprojx, settings and files
target testboard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: testboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\core;..\user;..\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group core
    ../core/: startup_stm32f051x8.s system_stm32f0xx.c stm32f0xx_it.c
  group user
    ../user/: main.c led.c uart.c menu.c flash_if.c common.c ymodem.c
  group lib
    ../lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_flash.c
