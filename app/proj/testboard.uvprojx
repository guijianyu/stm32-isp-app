# Keil uVision project testboard.uvprojx, settings and files
target testboard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: testboard +hex
  AfterMake: fromelf.exe --bin -o ./Objects/testboard.bin ./Objects/testboard.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\core;..\user;..\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group core
    ../core/: startup_stm32f051x8.s system_stm32f0xx.c stm32f0xx_it.c
  group user
    ../user/: main.c led.c uart.c fun.c stepmotor.c adc.c common.c flash_if.c iso_i2c_gpio.c iso_i2c_gpio_ee.c gpio.c dlp_control.c bsp_key.c bsp_delay.c xfm10213_model.c IWDG_model.c
  group lib
    ../lib/src/: stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_syscfg.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_exti.c stm32f0xx_rtc.c stm32f0xx_pwr.c
